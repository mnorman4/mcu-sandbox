# Keil uVision project host_msd_fatfs_bm.uvprojx, settings and files
target host_msd_fatfs_bm Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: host_msd_fatfs_bm.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG=1, CPU_MK64FN1M0VMD12, USB_STACK_BM, FRDM_K64F, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ..;../../../../../../middleware/fatfs_0.11a/src;../../../../../../middleware/fatfs_0.11a/src/fsl_usb_disk;../../../../../../devices/MK64F12/utilities;../../../../../../middleware/usb_1.0.0;../../../../../../middleware/usb_1.0.0/osa;../../../../../../middleware/usb_1.0.0/include;../../../../../../CMSIS/Include;../../../..;../../../../../../middleware/usb_1.0.0/host;../../../../../../devices/MK64F12/drivers;../../../../../../middleware/usb_1.0.0/host/class;../../../../../../devices/MK64F12
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../../devices/MK64F12/arm/: startup_MK64F12.s
    ../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group usb-host
    ../../../../../../middleware/usb_1.0.0/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group drivers
    ../../../../../../devices/MK64F12/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c
  group osa
    ../../../../../../middleware/usb_1.0.0/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-host-class
    ../../../../../../middleware/usb_1.0.0/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group sources
    ../: app.c host_msd_fatfs.c host_msd_fatfs.h usb_host_config.h
    ../../../../../../middleware/fatfs_0.11a/src/fsl_usb_disk/: fsl_usb_disk_bm.c fsl_usb_disk.h
  group sources-fatfs
    ../../../../../../middleware/fatfs_0.11a/src/: diskio.c diskio.h ff.c ff.h
    ../../../../../../middleware/fatfs_0.11a/src/option/: unicode.c
  group utilities
    ../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
  group usb-include
    ../../../../../../middleware/usb_1.0.0/include/: usb.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
target host_msd_fatfs_bm Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: host_msd_fatfs_bm.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: _DEBUG=0, CPU_MK64FN1M0VMD12, USB_STACK_BM, FRDM_K64F, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
