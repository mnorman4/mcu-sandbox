# IAR project host_hid_mouse_ucosii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MK64FN1M0VMD12; USB_STACK_UCOSII; FSL_RTOS_UCOSII; FRDM_K64F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/ucosii_2.92.11/uCOS-II/Ports/ARM-Cortex-M4/Generic/IAR; ../../../../../../rtos/ucosii_2.92.11/uC-CPU/ARM-Cortex-M4/IAR; ..; ../../../../../../rtos/ucosii_2.92.11/uCOS-II/Source; ../../../../../../rtos/ucosii_2.92.11/uC-CPU; ../../../../../../rtos/ucosii_2.92.11/uC-LIB; ../../../../../../devices/MK64F12/utilities; ../../../../../../middleware/usb_1.0.0; ../../../../../../middleware/usb_1.0.0/osa; ../../../../../../middleware/usb_1.0.0/include; ../../../../../../CMSIS/Include; ../../../..; ../../../../../../middleware/usb_1.0.0/host; ../../../../../../devices/MK64F12/drivers; ../../../../../../middleware/usb_1.0.0/host/class; ../../../../../../devices/MK64F12
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: host_hid_mouse_ucosii.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK64FN1M0VMD12; USB_STACK_UCOSII; FSL_RTOS_UCOSII; FRDM_K64F; FREEDOM
  ICCARM.CCOptLevel: 3
  group ucosii
    ../../../../../../rtos/ucosii_2.92.11/uCOS-II/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c fsl_isr_wrapper.S
    ../../../../../../rtos/ucosii_2.92.11/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group startup
    ../../../../../../devices/MK64F12/iar/: startup_MK64F12.s
    ../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group usb/host
    ../../../../../../middleware/usb_1.0.0/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb_1.0.0/host/class/: usb_host_hid.c usb_host_hid.h usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h
  group usb/include
    ../../../../../../middleware/usb_1.0.0/include/: usb.h
  group drivers
    ../../../../../../devices/MK64F12/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c
  group osa
    ../../../../../../middleware/usb_1.0.0/osa/: usb_osa.h usb_osa_ucosii.h usb_osa_ucosii.c
  group sources
    ../: app.c host_mouse.c host_mouse.h usb_host_config.h os_cfg.h cpu_cfg.h app_cfg.h
  group utilities
    ../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
