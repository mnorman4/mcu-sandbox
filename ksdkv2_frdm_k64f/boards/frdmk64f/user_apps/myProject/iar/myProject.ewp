# IAR project myProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\../CMSIS/Include; ..\..\..\..\../devices; ..\..\..\..\../devices/MK64F12; ..\..\..\..\../devices/MK64F12/utilities; ..\..\..\..\../devices/MK64F12/drivers; ../../..; ../
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: myProject.out
  ILINK.IlinkIcfFile: ..\..\..\..\../devices/MK64F12/iar/MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../../devices/MK64F12/iar/: MK64FN1M0xxx12_flash.icf
  group startup
    ../../../../../devices/MK64F12/iar/: startup_MK64F12.s
    ../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group CMSIS
    ../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_cm4.h
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h
  group board
    ../: board.c board.h pin_mux.c pin_mux.h clock_config.c clock_config.h
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_cmt.c fsl_cmt.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi_edma.c fsl_dspi.h fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.c fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c_edma.c fsl_i2c.h fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_mpu.c fsl_mpu.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rnga.c fsl_rnga.h fsl_rtc.c fsl_rtc.h fsl_sai.c fsl_sai_edma.c fsl_sai.h fsl_sai_edma.h fsl_sdhc.c fsl_sdhc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart_edma.c fsl_uart.h fsl_uart_edma.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
  group utilities
    ../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
  group sources
    ../: main.c main.h
