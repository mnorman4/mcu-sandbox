# Keil uVision project myProject.uvprojx, settings and files
target myProject Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  output: myProject.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VLL12
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186,66,111,223  --library_interface=armcc
  c include: ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK64F12; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/utilities; ../../; ../
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x100000
  memory RVCT9: RAM 0x1FFF0000 size 0x00010000
  memory RVCT10: RAM 0x20000000 size 0x00030000
  scatter file: ../../../../../devices/MK64F12/arm/MK64FN1M0xxx12_flash.scf
  group startup
    ../../../../../devices/MK64F12/arm/: startup_MK64F12.s MK64FN1M0xxx12_flash.scf
    ../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group CMSIS
    ../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_cm4.h
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_cmt.c fsl_cmt.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi_edma.c fsl_dspi.h fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.c fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c_edma.c fsl_i2c.h fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_mpu.c fsl_mpu.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rnga.c fsl_rnga.h fsl_rtc.c fsl_rtc.h fsl_sai.c fsl_sai_edma.c fsl_sai.h fsl_sai_edma.h fsl_sdhc.c fsl_sdhc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart_edma.c fsl_uart.h fsl_uart_edma.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
  group utilities
    ../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: board.c board.h pin_mux.c pin_mux.h clock_config.c clock_config.h
  group sources
    ../: main.c main.h
target myProject Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  output: myProject.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VLL12
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  --library_interface=armcc
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x100000
  memory RVCT9: RAM 0x1FFF0000 size 0x00010000
  memory RVCT10: RAM 0x20000000 size 0x00030000
  scatter file: ../../../../../devices/MK64F12/arm/MK64FN1M0xxx12_flash.scf
